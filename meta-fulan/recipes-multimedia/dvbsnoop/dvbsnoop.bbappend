
SRC_URI_remove_sh4 = "file://0001-Add-missing-capabilities-checks.patch"

