OPTIONAL_PACKAGES_remove_sh4 = " \
    gdb \
    v4l-utils \
    dvb-apps \
    wscan \
    "

OPTIONAL_PACKAGES += " \
    exteplayer3 \
    "

ENIGMA2_OPTIONAL += " \
    enigma2-plugin-extensions-serviceapp \
    "

