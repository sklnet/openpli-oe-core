SRC_URI_xpeedlx = "${GITHUB_URI}/sklnet/openpli-enigma2.git;branch=${ENIGMA2_BRANCH}"
